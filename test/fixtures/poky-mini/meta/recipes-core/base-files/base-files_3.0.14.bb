SUMMARY = "Miscellaneous files for the base system"
LICENSE = "GPL-2.0-only"
