SUMMARY = "Tiny versions of many common UNIX utilities in a single small executable"
LICENSE = "GPL-2.0-only & bzip2-1.0.4"
SRC_URI = "https://busybox.net/downloads/busybox-${PV}.tar.bz2 \
           file://defconfig \
           file://syslog-startup.conf \
           "
