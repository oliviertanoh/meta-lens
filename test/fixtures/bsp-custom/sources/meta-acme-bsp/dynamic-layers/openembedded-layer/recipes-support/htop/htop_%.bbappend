# Enabled: openembedded-layer is loaded.
