# "3.%" matches base-files_3.0.14.bb
