FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://acme.cfg"
