# Overlays meta/recipes-connectivity/openssh (same PN, higher priority).
SUMMARY = "ACME patched OpenSSH"
