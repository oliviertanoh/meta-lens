# Orphan: no psplash_1.2 recipe in any layer.
SRC_URI += "file://acme-splash.png"
