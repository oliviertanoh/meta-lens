SUMMARY = "ACME production image"
inherit core-image
