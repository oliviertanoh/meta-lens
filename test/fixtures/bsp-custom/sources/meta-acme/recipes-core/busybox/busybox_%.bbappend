SRC_URI_append = " file://syslog-acme.patch"
