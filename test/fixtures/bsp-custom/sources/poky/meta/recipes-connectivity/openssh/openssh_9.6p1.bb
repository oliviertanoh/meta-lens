SUMMARY = "A suite of security-related network utilities based on the SSH protocol"
