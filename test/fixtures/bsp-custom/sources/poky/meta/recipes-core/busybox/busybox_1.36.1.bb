SUMMARY = "Tiny versions of many common UNIX utilities"
SRC_URI = "https://busybox.net/downloads/busybox-${PV}.tar.bz2 file://defconfig"
