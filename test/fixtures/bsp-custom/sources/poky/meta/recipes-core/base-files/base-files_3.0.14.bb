SUMMARY = "Miscellaneous files for the base system"
