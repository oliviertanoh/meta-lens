SUMMARY = "Interactive process viewer"
