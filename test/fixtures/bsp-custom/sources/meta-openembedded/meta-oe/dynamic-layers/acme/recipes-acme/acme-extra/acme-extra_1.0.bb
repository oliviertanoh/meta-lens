SUMMARY = "Enabled because the acme collection is loaded"
