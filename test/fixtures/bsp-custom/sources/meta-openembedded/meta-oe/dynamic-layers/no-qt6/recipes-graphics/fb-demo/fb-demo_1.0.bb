SUMMARY = "Enabled because qt6-layer is NOT loaded"
